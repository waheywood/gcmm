if 10 != 3 (
    print 1
)