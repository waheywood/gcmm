if 1 > 3 {
    print 1
}